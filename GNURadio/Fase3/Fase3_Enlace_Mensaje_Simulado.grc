options:
  parameters:
    author: Grupo A1-GI
    description: Mismo Tx y Rx de mensajes con un canal que imita dos radios reales (referencia sin hardware)
    generate_options: qt_gui
    id: Fase3_Enlace_Mensaje_Simulado
    output_language: python
    title: Fase 3 A1-GI - Enlace 16-QAM de mensajes (simulado)
  states: {}

blocks:
- name: div
  id: variable
  parameters:
    value: '40'
    comment: 'Divisor del reloj maestro (100 MHz) del USRP-2920: 8 -> 12,5 MS/s; 40 -> 2,5 MS/s (modo seguro)'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6/div
    comment: El USRP solo admite 100 MHz / N
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: samp_rate/Sps
    comment: Rs = 625 kbaud con div = 40
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    value: lab.TABLA
    comment: 16QAM Gray normalizada (misma de la Fase 2)
  states: {}
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: span
  id: variable
  parameters:
    value: '11'
  states: {}
- name: beta
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: rrc_tx_taps
  id: variable_rrc_filter_taps
  parameters:
    gain: Sps
    samp_rate: samp_rate
    sym_rate: Rs
    alpha: beta
    ntaps: span*Sps
  states: {}
- name: fc
  id: variable
  parameters:
    value: 920e6
    comment: 'Banda de uso libre 915-928 MHz (Res. ANE 105/2020): canal 919,58-920,42 MHz'
  states: {}
- name: lo_off
  id: variable
  parameters:
    value: '-8e6'
    comment: 'LO en 912 MHz: la fuga del oscilador queda fuera del canal (ojo: 912 MHz esta fuera de 915-928 MHz; +6e6 la dejaria dentro)'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
    comment: IP por defecto del NI USRP-2920
  states: {}
- name: import_0
  id: import
  parameters:
    imports: |-
      import math
      from gnuradio import digital
      from gnuradio.filter import firdes
  states: {}
- name: lab
  id: epy_module
  parameters:
    source_code: |
      """Utilidades del enlace 16-QAM del grupo A1-GI (Fase 3, laboratorio)."""
      import math

      # Constelacion 16-QAM Gray normalizada (Es = 1): b3b2 -> I, b1b0 -> Q
      TABLA = [p / math.sqrt(10) for p in (-3-3j, -3-1j, -3+3j, -3+1j, -1-3j, -1-1j, -1+3j, -1+1j,
                                             3-3j, 3-1j, 3+3j, 3+1j, 1-3j, 1-1j, 1+3j, 1+1j)]


      def prbs15():
          """Secuencia PRBS15 (x^15 + x^14 + 1), periodo 32767 bits: b[n] = b[n-14] xor b[n-15]."""
          s = [1] * 15
          out = []
          for _ in range(2 ** 15 - 1):
              b = s[13] ^ s[14]
              out.append(s[14])
              s = [b] + s[:-1]
          return out


      def mapa_rotacion(k):
          """Indice del punto que resulta de rotar cada punto k*90 grados."""
          r = []
          for p in TABLA:
              q = p * (1j ** k)
              r.append(min(range(16), key=lambda i: abs(q - TABLA[i])))
          return r


      # ---------------- Tramas de texto (transmisor con mensaje) ----------------
      import zlib as _zlib

      BITS_TRAMA = 8192                 # 2048 simbolos 16-QAM por trama
      MAX_BYTES = (BITS_TRAMA - 64 - 32 - 32) // 8   # 1008 bytes de texto
      import numpy as _np
      SYNC = [int(b) for b in _np.random.RandomState(27145).randint(0, 2, 64)]   # palabra de sincronismo
      _BLANQUEO = None


      def _bits(valor, n):
          return [(valor >> (n - 1 - i)) & 1 for i in range(n)]


      def trama_bits(mensaje):
          """SYNC(64) | blanqueado( LONG(16) | ~LONG(16) | TEXTO | CRC32 | relleno ) = 8192 bits."""
          global _BLANQUEO
          if _BLANQUEO is None:
              _BLANQUEO = prbs15()[:BITS_TRAMA - 64]
          datos = str(mensaje).encode('utf-8')[:MAX_BYTES]
          largo = len(datos)
          cuerpo = _bits(largo, 16) + _bits(largo ^ 0xFFFF, 16)
          for byte in datos:
              cuerpo += _bits(byte, 8)
          cuerpo += _bits(_zlib.crc32(datos) & 0xFFFFFFFF, 32)
          cuerpo += [0] * (BITS_TRAMA - 64 - len(cuerpo))
          return SYNC + [c ^ w for c, w in zip(cuerpo, _BLANQUEO)]


      def trama_bytes(mensaje):
          """La misma trama empaquetada en 1024 bytes (MSB primero). Cada byte = 2 simbolos 16-QAM,
          asi un cambio de mensaje en vivo nunca parte un simbolo por la mitad."""
          b = trama_bits(mensaje)
          return [sum(b[i + j] << (7 - j) for j in range(8)) for i in range(0, len(b), 8)]
    comment: Tabla, PRBS15 y utilidades
  states: {}
- name: tx_escala
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: mensaje
  id: variable_qtgui_entry
  parameters:
    label: Mensaje a transmitir (escriba y presione Enter)
    type: string
    value: 'Hola desde el grupo A1-GI: enlace 16-QAM simulado'
    gui_hint: 6,0,1,4
  states: {}
- name: EsN0_dB
  id: variable_qtgui_range
  parameters:
    label: Es/N0 [dB]
    start: '5'
    stop: '40'
    step: '0.5'
    value: '25'
    gui_hint: 0,0,1,1
  states: {}
- name: desfase_hz
  id: variable_qtgui_range
  parameters:
    label: Desfase de portadora [Hz]
    start: '-20000'
    stop: '20000'
    step: '500'
    value: '4000'
    gui_hint: 0,1,1,1
  states: {}
- name: ppm_reloj
  id: variable_qtgui_range
  parameters:
    label: Error de reloj [ppm]
    start: '-20'
    stop: '20'
    step: '1'
    value: '5'
    gui_hint: 1,0,1,1
  states: {}
- name: ruido_v
  id: variable
  parameters:
    value: math.sqrt(tx_escala**2*sum(t*t for t in rrc_tx_taps)/10**(EsN0_dB/10))
    comment: Es/N0 referido a la senal escalada
  states: {}
- name: fuente_prbs
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: lab.trama_bytes(mensaje)
    repeat: 'True'
    comment: Trama de 1024 bytes con el texto escrito en la ventana (SYNC + longitud + texto + CRC32, blanqueada con PRBS15)
  states: {}
- name: bits_to_symbols
  id: blocks_repack_bits_bb
  parameters:
    k: '8'
    l: bps
    endianness: gr.GR_MSB_FIRST
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    in_type: byte
    out_type: complex
    symbol_table: tabla_de_verdad_constelacion
    dimension: '1'
  states: {}
- name: rrc_tx
  id: interp_fir_filter_xxx
  parameters:
    type: ccf
    interp: Sps
    taps: rrc_tx_taps
  states: {}
- name: escala_tx
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: tx_escala
    comment: 'Pico de la senal RRC ~2: x0,45 evita saturar el DAC (|x|<1)'
  states: {}
- name: throttle_0
  id: blocks_throttle2
  parameters:
    type: complex
    samples_per_second: samp_rate
    comment: 'Solo en simulacion: con radio real el SDR fija el ritmo'
  states: {}
- name: canal_radio
  id: channels_channel_model
  parameters:
    noise_voltage: ruido_v
    freq_offset: desfase_hz/samp_rate
    epsilon: 1+ppm_reloj*1e-6
    taps: '[1.0]'
    seed: '0'
    comment: Imita dos radios independientes
  states: {}
- name: psd_rx
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"Espectro a la entrada del receptor"'
    fftsize: '2048'
    fc: '0'
    bw: samp_rate
    average: '0.2'
    ymin: '-120'
    ymax: '0'
    grid: 'True'
    update_time: '0.1'
    gui_hint: 2,0,1,4
    label1: Senal
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_mf_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts*samp_rate, Rs, beta, span*Sps*nfilts)
    comment: Filtro acoplado RRC dentro del Symbol Sync
  states: {}
- name: constelacion_16qam
  id: variable
  parameters:
    value: digital.constellation_calcdist(tabla_de_verdad_constelacion, [], 4, 1, digital.constellation.NO_NORMALIZATION)
  states: {}
- name: ref_agc
  id: variable
  parameters:
    value: sum(abs(p) for p in tabla_de_verdad_constelacion)/M
  states: {}
- name: lazo_simbolo
  id: variable_qtgui_range
  parameters:
    label: Ancho de lazo sincronismo de simbolo
    start: '0.005'
    stop: '0.1'
    step: '0.005'
    value: '0.02'
    gui_hint: 0,2,1,1
  states: {}
- name: lazo_portadora
  id: variable_qtgui_range
  parameters:
    label: Ancho de lazo de portadora [rad/simb]
    start: '0.002'
    stop: '0.06'
    step: '0.001'
    value: '0.016'
    gui_hint: 0,3,1,1
  states: {}
- name: rx_agc_muestras
  id: analog_agc2_xx
  parameters:
    type: complex
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    reference: '1.0'
    gain: '1.0'
    max_gain: '65536'
    comment: Normaliza el nivel recibido
  states: {}
- name: rx_sinc_simbolo
  id: digital_symbol_sync_xx
  parameters:
    type: cc
    ted_type: digital.TED_GARDNER
    constellation: constelacion_16qam
    sps: Sps
    ted_gain: '1.0'
    loop_bw: lazo_simbolo
    damping: '1.0'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_PFB_MF
    nfilters: nfilts
    pfb_mf_taps: rrc_mf_taps
    comment: Filtro acoplado RRC + recuperacion de reloj (Gardner)
  states: {}
- name: rx_agc_simbolos
  id: analog_agc_xx
  parameters:
    type: complex
    rate: '1e-3'
    reference: ref_agc
    gain: '1.0'
    max_gain: '1000'
    comment: AGC de la Fase 2
  states: {}
- name: rx_portadora
  id: digital_constellation_receiver_cb
  parameters:
    constellation: constelacion_16qam
    loop_bw: lazo_portadora
    fmin: '-0.25'
    fmax: '0.25'
    comment: Lazo de portadora dirigido por decision + decisor
  states: {}
- name: salidas_libres
  id: blocks_null_sink
  parameters:
    type: float
    num_inputs: '2'
  states: {}
- name: ber_prbs
  id: epy_block
  parameters:
    _source_code: |
      """
      Decodificador de tramas de texto para el enlace 16-QAM (grupo A1-GI).

      Trama del transmisor (8192 bits = 2048 simbolos 16-QAM):
        SYNC (64 bits) | blanqueado( LONG(16) | ~LONG(16) | TEXTO UTF-8 | CRC32(32) | ceros de relleno )
      El blanqueado es un XOR con la secuencia PRBS15: mantiene la senal "aleatoria" aunque el texto
      se repita (espectro plano y transiciones para el sincronismo de simbolo).

      Entrada: indices de simbolo decididos (0..15) a la salida del Constellation Receiver.
      El lazo de portadora puede engancharse girado 0/90/180/270 grados: la palabra SYNC se busca en
      las cuatro rotaciones y la que aparece fija la rotacion con que se leen las tramas.

      Salidas (float, una muestra por simbolo):
        0: tramas correctas (CRC bien)   1: tramas con error
        2: BER medido sobre bits conocidos (SYNC + relleno)   3: rotacion detectada (0..3)
      Puerto de mensaje 'texto': ultimo mensaje recibido con CRC correcto.
      """
      import zlib
      import numpy as np
      import pmt
      from gnuradio import gr

      TABLA = np.array([-3-3j, -3-1j, -3+3j, -3+1j, -1-3j, -1-1j, -1+3j, -1+1j,
                        3-3j, 3-1j, 3+3j, 3+1j, 1-3j, 1-1j, 1+3j, 1+1j]) / np.sqrt(10)
      BITS_TRAMA = 8192
      SIMB_TRAMA = BITS_TRAMA // 4


      def _mapa(k):
          q = TABLA * (1j ** k)
          return np.array([np.argmin(np.abs(TABLA - v)) for v in q], dtype=np.uint8)


      def _prbs15(n):
          s = [1] * 15
          out = []
          for _ in range(n):
              b = s[13] ^ s[14]
              out.append(s[14])
              s = [b] + s[:-1]
          return np.array(out, dtype=np.uint8)


      SYNC = np.random.RandomState(27145).randint(0, 2, 64).astype(np.uint8)
      SYNC_SIMB = (SYNC.reshape(-1, 4) * np.array([8, 4, 2, 1])).sum(1).astype(np.uint8)
      BLANQUEO = _prbs15(BITS_TRAMA - 64)
      PESOS = np.array([3, 2, 1, 0], dtype=np.uint8)


      def _entero(bits):
          v = 0
          for b in bits:
              v = (v << 1) | int(b)
          return v


      class blk(gr.sync_block):
          def __init__(self, ventana_tramas=50):
              gr.sync_block.__init__(self, name='Decodificador de mensajes 16-QAM',
                                     in_sig=[np.uint8], out_sig=[np.float32] * 4)
              self.message_port_register_out(pmt.intern('texto'))
              self.ventana_tramas = ventana_tramas
              self._mapas = [_mapa(k) for k in range(4)]
              self._buf = np.zeros(0, dtype=np.uint8)
              self._enganchado = False
              self._rot = 0
              self._malas = 0
              self._ok = 0
              self._mal = 0
              self._err = 0
              self._nb = 0
              self._tramas_ventana = 0
              self._ber = 0.5
              self._ultimo = None

          def _buscar(self):
              mejor = None
              if len(self._buf) < 16:
                  return None
              for k in range(4):
                  t = self._mapas[k][self._buf]
                  v = np.lib.stride_tricks.sliding_window_view(t, 16)
                  aciertos = (v == SYNC_SIMB).sum(axis=1)
                  i = int(np.argmax(aciertos))
                  if aciertos[i] >= 13 and (mejor is None or aciertos[i] > mejor[2] or
                                            (aciertos[i] == mejor[2] and i < mejor[0])):
                      mejor = (i, k, int(aciertos[i]))
              return mejor

          def _decodificar(self, trama):
              idx = self._mapas[self._rot][trama]
              bits = ((idx[:, None] >> PESOS) & 1).astype(np.uint8).ravel()
              err_sync = int((bits[:64] ^ SYNC).sum())
              cuerpo = bits[64:] ^ BLANQUEO
              largo, largo_c = _entero(cuerpo[:16]), _entero(cuerpo[16:32])
              err, nb = err_sync, 64
              valida = False
              if (largo ^ largo_c) == 0xFFFF and 32 + 8 * largo + 32 <= len(cuerpo):
                  fin = 32 + 8 * largo
                  datos = np.packbits(cuerpo[32:fin]).tobytes()
                  crc = _entero(cuerpo[fin:fin + 32])
                  relleno = cuerpo[fin + 32:]
                  err += int(relleno.sum())
                  nb += len(relleno)
                  if zlib.crc32(datos) & 0xFFFFFFFF == crc:
                      valida = True
                      texto = datos.decode('utf-8', errors='replace')
                      if texto != self._ultimo:
                          self._ultimo = texto
                          print('Mensaje recibido:', texto, flush=True)
                          self.message_port_pub(pmt.intern('texto'), pmt.intern(texto))
              if valida:
                  self._ok += 1
              else:
                  self._mal += 1
              self._err += err
              self._nb += nb
              self._tramas_ventana += 1
              if self._tramas_ventana >= self.ventana_tramas:
                  self._ber = self._err / max(self._nb, 1)
                  self._err = self._nb = self._tramas_ventana = 0
              # Perdida de enganche: SYNC muy danada en tres tramas seguidas
              self._malas = self._malas + 1 if err_sync > 16 else 0
              if self._malas >= 3:
                  self._enganchado = False
                  self._malas = 0

          def work(self, input_items, output_items):
              sym = input_items[0] & 0x0F
              n = len(sym)
              self._buf = np.concatenate([self._buf, sym])
              while True:
                  if not self._enganchado:
                      hallado = self._buscar()
                      if hallado is None:
                          self._buf = self._buf[-15:]
                          break
                      self._buf = self._buf[hallado[0]:]
                      self._rot = hallado[1]
                      self._enganchado = True
                  if len(self._buf) < SIMB_TRAMA:
                      break
                  trama, self._buf = self._buf[:SIMB_TRAMA], self._buf[SIMB_TRAMA:]
                  self._decodificar(trama)
              output_items[0][:] = self._ok
              output_items[1][:] = self._mal
              output_items[2][:] = self._ber
              output_items[3][:] = self._rot
              return n
    ventana_tramas: '50'
    comment: Busca la palabra SYNC en las 4 rotaciones, verifica CRC32 y entrega el texto
  states: {}
- name: ber_num
  id: qtgui_number_sink
  parameters:
    name: '"Recepcion de tramas"'
    type: float
    nconnections: '4'
    min: '0'
    label1: Tramas correctas (CRC ok)
    label2: Tramas con error
    label3: BER (bits conocidos)
    label4: Rotacion detectada
    graph_type: qtgui.NUM_GRAPH_NONE
    update_time: '0.25'
    gui_hint: 3,2,2,2
  states: {}
- name: probe_ber
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_ok
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: mensaje_rx
  id: qtgui_edit_box_msg
  parameters:
    type: string
    label: '"Mensaje recibido"'
    is_pair: 'False'
    is_static: 'False'
    gui_hint: 7,0,1,4
  states: {}
- name: rx_punto_ideal
  id: digital_chunks_to_symbols_xx
  parameters:
    in_type: byte
    out_type: complex
    symbol_table: tabla_de_verdad_constelacion
    dimension: '1'
  states: {}
- name: evm_error
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: evm_mag2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: evm_promedio
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: '20000'
    scale: 1/20000
    max_iter: '4000'
  states: {}
- name: evm_raiz
  id: blocks_transcendental
  parameters:
    type: float
    name: sqrt
  states: {}
- name: evm_pct
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: '100'
  states: {}
- name: cfo_promedio
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: '10000'
    scale: 1/10000
    max_iter: '4000'
  states: {}
- name: cfo_hz
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: '-Rs/(2*math.pi)'
    comment: 'rad/simbolo -> Hz (signo: desfase del canal)'
  states: {}
- name: medidas_num
  id: qtgui_number_sink
  parameters:
    name: '"Medidas del enlace"'
    type: float
    nconnections: '2'
    min: '-10000'
    max: '10000'
    label1: EVM rms [%]
    label2: Desfase de portadora estimado [Hz]
    unit1: '%'
    unit2: Hz
    graph_type: qtgui.NUM_GRAPH_NONE
    update_time: '0.25'
    gui_hint: 5,2,1,2
  states: {}
- name: probe_evm
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_cfo
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: const_sinc
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: '"Tras sincronismo de simbolo (antes del lazo de portadora)"'
    size: '2048'
    xmin: '-1.5'
    xmax: '1.5'
    ymin: '-1.5'
    ymax: '1.5'
    label1: '"Simbolos"'
    grid: 'True'
    legend: 'False'
    update_time: '0.1'
    gui_hint: 3,0,3,1
  states: {}
- name: const_rx
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: '"Constelacion recuperada"'
    size: '2048'
    xmin: '-1.5'
    xmax: '1.5'
    ymin: '-1.5'
    ymax: '1.5'
    label1: '"Rx"'
    grid: 'True'
    legend: 'False'
    update_time: '0.1'
    gui_hint: 3,1,3,1
  states: {}

connections:
- [fuente_prbs, '0', bits_to_symbols, '0']
- [bits_to_symbols, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', rrc_tx, '0']
- [rrc_tx, '0', escala_tx, '0']
- [escala_tx, '0', throttle_0, '0']
- [throttle_0, '0', canal_radio, '0']
- [canal_radio, '0', psd_rx, '0']
- [rx_portadora, '1', salidas_libres, '0']
- [rx_portadora, '2', salidas_libres, '1']
- [canal_radio, '0', rx_agc_muestras, '0']
- [rx_agc_muestras, '0', rx_sinc_simbolo, '0']
- [rx_sinc_simbolo, '0', rx_agc_simbolos, '0']
- [rx_agc_simbolos, '0', rx_portadora, '0']
- [rx_portadora, '0', ber_prbs, '0']
- [ber_prbs, '0', ber_num, '0']
- [ber_prbs, '1', ber_num, '1']
- [ber_prbs, '2', ber_num, '2']
- [ber_prbs, '3', ber_num, '3']
- [ber_prbs, '2', probe_ber, '0']
- [ber_prbs, '0', probe_ok, '0']
- [ber_prbs, texto, mensaje_rx, val]
- [rx_portadora, '0', rx_punto_ideal, '0']
- [rx_portadora, '4', evm_error, '0']
- [rx_punto_ideal, '0', evm_error, '1']
- [evm_error, '0', evm_mag2, '0']
- [evm_mag2, '0', evm_promedio, '0']
- [evm_promedio, '0', evm_raiz, '0']
- [evm_raiz, '0', evm_pct, '0']
- [rx_portadora, '3', cfo_promedio, '0']
- [cfo_promedio, '0', cfo_hz, '0']
- [evm_pct, '0', medidas_num, '0']
- [cfo_hz, '0', medidas_num, '1']
- [evm_pct, '0', probe_evm, '0']
- [cfo_hz, '0', probe_cfo, '0']
- [rx_agc_simbolos, '0', const_sinc, '0']
- [rx_portadora, '4', const_rx, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
