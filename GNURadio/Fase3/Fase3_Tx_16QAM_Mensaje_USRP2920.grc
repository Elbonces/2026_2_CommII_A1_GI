options:
  parameters:
    author: Grupo A1-GI
    description: Transmisor 16-QAM que envia en tramas el texto escrito en la ventana
    generate_options: qt_gui
    id: Fase3_Tx_16QAM_Mensaje_USRP2920
    output_language: python
    title: Fase 3 A1-GI - Transmisor 16-QAM de mensajes (USRP-2920)
  states: {}

blocks:
- name: div
  id: variable
  parameters:
    value: '40'
    comment: 'Divisor del reloj maestro (100 MHz) del USRP-2920: 8 -> 12,5 MS/s; 40 -> 2,5 MS/s (modo seguro)'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6/div
    comment: El USRP solo admite 100 MHz / N
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: samp_rate/Sps
    comment: Rs = 625 kbaud con div = 40
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    value: lab.TABLA
    comment: 16QAM Gray normalizada (misma de la Fase 2)
  states: {}
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: span
  id: variable
  parameters:
    value: '11'
  states: {}
- name: beta
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: rrc_tx_taps
  id: variable_rrc_filter_taps
  parameters:
    gain: Sps
    samp_rate: samp_rate
    sym_rate: Rs
    alpha: beta
    ntaps: span*Sps
  states: {}
- name: fc
  id: variable
  parameters:
    value: 920e6
    comment: 'Banda de uso libre 915-928 MHz (Res. ANE 105/2020): canal 919,58-920,42 MHz'
  states: {}
- name: lo_off
  id: variable
  parameters:
    value: '-8e6'
    comment: 'LO en 912 MHz: la fuga del oscilador queda fuera del canal (ojo: 912 MHz esta fuera de 915-928 MHz; +6e6 la dejaria dentro)'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
    comment: IP por defecto del NI USRP-2920
  states: {}
- name: import_0
  id: import
  parameters:
    imports: |-
      import math
      from gnuradio import digital
      from gnuradio.filter import firdes
  states: {}
- name: lab
  id: epy_module
  parameters:
    source_code: |
      """Utilidades del enlace 16-QAM del grupo A1-GI (Fase 3, laboratorio)."""
      import math

      # Constelacion 16-QAM Gray normalizada (Es = 1): b3b2 -> I, b1b0 -> Q
      TABLA = [p / math.sqrt(10) for p in (-3-3j, -3-1j, -3+3j, -3+1j, -1-3j, -1-1j, -1+3j, -1+1j,
                                             3-3j, 3-1j, 3+3j, 3+1j, 1-3j, 1-1j, 1+3j, 1+1j)]


      def prbs15():
          """Secuencia PRBS15 (x^15 + x^14 + 1), periodo 32767 bits: b[n] = b[n-14] xor b[n-15]."""
          s = [1] * 15
          out = []
          for _ in range(2 ** 15 - 1):
              b = s[13] ^ s[14]
              out.append(s[14])
              s = [b] + s[:-1]
          return out


      def mapa_rotacion(k):
          """Indice del punto que resulta de rotar cada punto k*90 grados."""
          r = []
          for p in TABLA:
              q = p * (1j ** k)
              r.append(min(range(16), key=lambda i: abs(q - TABLA[i])))
          return r


      # ---------------- Tramas de texto (transmisor con mensaje) ----------------
      import zlib as _zlib

      BITS_TRAMA = 8192                 # 2048 simbolos 16-QAM por trama
      MAX_BYTES = (BITS_TRAMA - 64 - 32 - 32) // 8   # 1008 bytes de texto
      import numpy as _np
      SYNC = [int(b) for b in _np.random.RandomState(27145).randint(0, 2, 64)]   # palabra de sincronismo
      _BLANQUEO = None


      def _bits(valor, n):
          return [(valor >> (n - 1 - i)) & 1 for i in range(n)]


      def trama_bits(mensaje):
          """SYNC(64) | blanqueado( LONG(16) | ~LONG(16) | TEXTO | CRC32 | relleno ) = 8192 bits."""
          global _BLANQUEO
          if _BLANQUEO is None:
              _BLANQUEO = prbs15()[:BITS_TRAMA - 64]
          datos = str(mensaje).encode('utf-8')[:MAX_BYTES]
          largo = len(datos)
          cuerpo = _bits(largo, 16) + _bits(largo ^ 0xFFFF, 16)
          for byte in datos:
              cuerpo += _bits(byte, 8)
          cuerpo += _bits(_zlib.crc32(datos) & 0xFFFFFFFF, 32)
          cuerpo += [0] * (BITS_TRAMA - 64 - len(cuerpo))
          return SYNC + [c ^ w for c, w in zip(cuerpo, _BLANQUEO)]


      def trama_bytes(mensaje):
          """La misma trama empaquetada en 1024 bytes (MSB primero). Cada byte = 2 simbolos 16-QAM,
          asi un cambio de mensaje en vivo nunca parte un simbolo por la mitad."""
          b = trama_bits(mensaje)
          return [sum(b[i + j] << (7 - j) for j in range(8)) for i in range(0, len(b), 8)]
    comment: Tabla, PRBS15 y utilidades
  states: {}
- name: tx_escala
  id: variable
  parameters:
    value: '0.45'
    comment: 'Back-off: PAPR de 16QAM+RRC = 6,3 dB'
  states: {}
- name: tx_ganancia
  id: variable_qtgui_range
  parameters:
    label: Ganancia Tx USRP [dB]
    start: '0'
    stop: '31'
    step: '1'
    value: '25'
    gui_hint: 0,0,1,2
  states: {}
- name: mensaje
  id: variable_qtgui_entry
  parameters:
    label: Mensaje a transmitir (escriba y presione Enter)
    type: string
    value: 'Hola desde el grupo A1-GI: enlace 16-QAM USRP -> HackRF'
    gui_hint: 5,0,1,2
  states: {}
- name: fuente_prbs
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: lab.trama_bytes(mensaje)
    repeat: 'True'
    comment: Trama de 1024 bytes con el texto escrito en la ventana (SYNC + longitud + texto + CRC32, blanqueada con PRBS15)
  states: {}
- name: bits_to_symbols
  id: blocks_repack_bits_bb
  parameters:
    k: '8'
    l: bps
    endianness: gr.GR_MSB_FIRST
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    in_type: byte
    out_type: complex
    symbol_table: tabla_de_verdad_constelacion
    dimension: '1'
  states: {}
- name: rrc_tx
  id: interp_fir_filter_xxx
  parameters:
    type: ccf
    interp: Sps
    taps: rrc_tx_taps
  states: {}
- name: escala_tx
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: tx_escala
    comment: 'Pico de la senal RRC ~2: x0,45 evita saturar el DAC (|x|<1)'
  states: {}
- name: usrp_tx
  id: uhd_usrp_sink
  parameters:
    type: fc32
    otw: sc16
    dev_addr: usrp_addr
    dev_args: '""'
    samp_rate: samp_rate
    center_freq0: uhd.tune_request(fc, lo_off)
    gain0: tx_ganancia
    ant0: '"TX/RX"'
    sync: none
    comment: 'Antena en TX/RX (sin Throttle: el USRP fija el ritmo)'
  states: {}
- name: psd_tx
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"PSD de la senal enviada al USRP"'
    fftsize: '2048'
    fc: fc
    bw: samp_rate
    average: '0.2'
    ymin: '-120'
    ymax: '0'
    grid: 'True'
    update_time: '0.1'
    gui_hint: 1,0,2,2
    label1: Senal
  states: {}
- name: const_tx
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: '"Constelacion transmitida (antes del RRC)"'
    size: '1024'
    xmin: '-1.5'
    xmax: '1.5'
    ymin: '-1.5'
    ymax: '1.5'
    label1: '"Tx"'
    grid: 'True'
    legend: 'False'
    update_time: '0.1'
    gui_hint: 3,0,2,1
  states: {}
- name: envolvente_tx
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: '"Envolvente enviada al DAC (debe quedar entre -1 y 1)"'
    size: '1024'
    srate: samp_rate
    ymin: '-1.2'
    ymax: '1.2'
    label1: I
    label2: Q
    grid: 'True'
    update_time: '0.1'
    entags: 'False'
    gui_hint: 3,1,2,1
    ylabel: Amplitud
  states: {}

connections:
- [fuente_prbs, '0', bits_to_symbols, '0']
- [bits_to_symbols, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', rrc_tx, '0']
- [rrc_tx, '0', escala_tx, '0']
- [escala_tx, '0', usrp_tx, '0']
- [escala_tx, '0', psd_tx, '0']
- [digital_chunks_to_symbols_xx_0, '0', const_tx, '0']
- [escala_tx, '0', envolvente_tx, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
