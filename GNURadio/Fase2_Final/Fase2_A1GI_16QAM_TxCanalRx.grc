options:
  parameters:
    author: Grupo A1-GI
    description: '16QAM Tx-Canal-Rx: RRC, canal LOS/EMI/sombra, filtro acoplado, muestreo, AGC, decisor, BER/EVM'
    generate_options: qt_gui
    id: Fase2_A1GI_16QAM_TxCanalRx
    output_language: python
    title: 'Fase 2 A1-GI: enlace 16-QAM Tx-Canal-Rx (inspeccion optica)'
  states: {}

blocks:
- name: E_pulso
  id: variable
  parameters:
    value: sum(t*t for t in rrc_tx_taps)
  states: {}
- name: EsN0_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Es/N0 LOS [dB]
    start: '0'
    step: '0.5'
    stop: '45'
    value: '30'
  states: {}
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '3000000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: agc_on
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 1,4,1,2
    label: AGC en el receptor
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: agc_rate
  id: variable
  parameters:
    value: '1e-3'
  states: {}
- name: atten_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Atenuacion por sombra [dB]
    start: '0'
    step: '1'
    stop: '25'
    value: '0'
  states: {}
- name: awgn_on
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 1,0,1,2
    label: AWGN de fondo
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: ber_win
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: beta
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,5,1,1
    label: Roll-off beta
    start: '0.1'
    step: '0.05'
    stop: '1.0'
    value: '0.35'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: constelacion_16qam
  id: variable
  parameters:
    value: digital.constellation_calcdist(tabla_de_verdad_constelacion, [], 4, 1, digital.constellation.NO_NORMALIZATION)
  states: {}
- name: d_muestreo
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Retardo de muestreo d [muestras]
    rangeType: int
    start: '0'
    step: '1'
    stop: '7'
    value: '7'
  states: {}
- name: emi_amp
  id: variable
  parameters:
    value: math.sqrt(E_pulso/Sps*10**(emi_isr_dB/10))
  states: {}
- name: emi_dur
  id: variable
  parameters:
    value: '1e-6'
  states: {}
- name: emi_isr_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: 'EMI: potencia rafaga/senal [dB]'
    start: '-15'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: emi_on
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 1,2,1,2
    label: EMI impulsiva (VFD/soldadura)
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: emi_rate
  id: variable
  parameters:
    value: 16e3
  states: {}
- name: g_sombra
  id: variable
  parameters:
    value: 10**(-atten_dB/20)
  states: {}
- name: modo_captura
  id: variable
  parameters:
    value: '0'
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: awgn_on*math.sqrt(E_pulso/10**(EsN0_dB/10))
  states: {}
- name: ref_agc
  id: variable
  parameters:
    value: sum(abs(p) for p in tabla_de_verdad_constelacion)/M
  states: {}
- name: retardo_ref
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: Retardo referencia BER [simbolos]
    rangeType: int
    start: '0'
    step: '1'
    stop: '30'
    value: '11'
  states: {}
- name: rrc_rx_taps
  id: variable
  parameters:
    value: '[t/E_pulso for t in rrc_tx_taps]'
  states: {}
- name: rrc_tx_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: beta
    gain: Sps
    ntaps: span*Sps
    samp_rate: samp_rate
    sym_rate: Rs
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: span
  id: variable
  parameters:
    value: '11'
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    value: '[p/math.sqrt(10) for p in (-3-3j, -3-1j, -3+3j, -3+1j, -1-3j, -1-1j, -1+3j, -1+1j, 3-3j, 3-1j, 3+3j, 3+1j, 1-3j, 1-1j, 1+3j, 1+1j)]'
  states: {}
- name: ber_float
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: ber_num
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 10,2,3,2
    label1: BER
    max: '0.5'
    min: '0'
    name: '"BER medida"'
    type: float
    update_time: '0.2'
  states: {}
- name: ber_promedio
  id: blocks_moving_average_xx
  parameters:
    length: ber_win
    max_iter: '4000'
    scale: 1.0/ber_win
    type: float
  states: {}
- name: ber_unpack
  id: blocks_unpack_k_bits_bb
  parameters:
    k: bps
  states: {}
- name: ber_xor
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: bits_a_simbolos
  id: blocks_repack_bits_bb
  parameters:
    comment: Agrupa 4 bits -> indice 0..15
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: bps
  states: {}
- name: canal_sombra
  id: blocks_multiply_const_vxx
  parameters:
    comment: 'Sombra: atenuacion de la senal'
    const: g_sombra
    type: complex
  states: {}
- name: canal_suma
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: captura_auto
  id: snippet
  parameters:
    code: |
      # --- Guion automatico de pruebas y capturas (solo corre si modo_captura == 1) ---
      import os, json, math, traceback
      from PyQt5 import QtCore
      if self.modo_captura:
          self.resize(1900, 1150)
          _dir = os.path.join(os.path.dirname(os.path.abspath(__file__)), 'capturas')
          os.makedirs(_dir, exist_ok=True)
          _res = {'escenarios': {}, 'barrido_muestreo': [], 'barrido_ber': [], 'alineacion': []}
          _W = {
              'psd_tx_canal': self._psd_tx_canal_win, 'psd_beta': self._psd_beta_win,
              'envolvente': self._envolvente_canal_win, 'const_canal': self._const_canal_win,
              'ojo': self._ojo_filtro_acoplado_win, 'const_rx': self._const_rx_win,
              'simbolos': self._simbolos_tx_rx_win, 'ber': self._ber_num_win, 'evm': self._evm_num_win,
          }
          def _grab(nombre, clave):
              _W[clave].grab().save(os.path.join(_dir, nombre + '.png'))
          def _guardar():
              with open(os.path.join(_dir, 'resultados.json'), 'w') as f:
                  json.dump(_res, f, indent=1)
          def _bits():
              return self.ber_promedio.nitems_read(0)
          def _esperar_bits(n):
              n0 = _bits()
              while _bits() - n0 < n:
                  yield
          def _esperar_ms(ms):
              t = QtCore.QElapsedTimer(); t.start()
              while t.elapsed() < ms:
                  yield
          def _conf(EsN0=30.0, awgn=1, att=0.0, emi=0, isr=0.0, d=7, agc=1, ref=None):
              self.set_EsN0_dB(EsN0); self.set_awgn_on(awgn); self.set_atten_dB(att)
              self.set_emi_on(emi); self.set_emi_isr_dB(isr); self.set_d_muestreo(d); self.set_agc_on(agc)
              if not agc:
                  self.rx_agc.set_gain(1.0)
              if ref is not None:
                  self.set_retardo_ref(ref)
          def _medir(nombre, k=3, extra=None):
              yield from _esperar_bits(2 * self.ber_win)
              b, e = [], []
              for i in range(k):
                  yield from _esperar_bits(self.ber_win)
                  b.append(self.probe_ber.level()); e.append(self.probe_evm.level())
              r = dict(ber=sum(b) / k, ber_lecturas=b, evm_pct=sum(e) / k, bits=k * self.ber_win,
                       EsN0_dB=self.EsN0_dB, awgn_on=self.awgn_on, atten_dB=self.atten_dB, emi_on=self.emi_on,
                       emi_isr_dB=self.emi_isr_dB, d_muestreo=self.d_muestreo, agc_on=self.agc_on,
                       retardo_ref=self.retardo_ref, noise_amp=self.noise_amp)
              if extra:
                  r.update(extra)
              _res['escenarios'][nombre] = r
              _guardar()
              return r
          def _guion():
              yield from _esperar_ms(3000)
              t0 = QtCore.QElapsedTimer(); t0.start(); n0 = _bits()
              yield from _esperar_ms(2000)
              _res['bits_por_segundo_simulados'] = (_bits() - n0) / (t0.elapsed() / 1000.0)
              # 1) Alineacion de la referencia (canal ideal, muestreo d=7)
              _conf(awgn=0, d=7, agc=1)
              mejor, mejor_ber = 11, 1.0
              for ref in range(6, 17):
                  self.set_retardo_ref(ref)
                  yield from _esperar_bits(3 * self.ber_win)
                  v = self.probe_ber.level()
                  _res['alineacion'].append([ref, v])
                  if v < mejor_ber:
                      mejor, mejor_ber = ref, v
              _res['retardo_ref_optimo'] = mejor
              _guardar()
              # 2) Canal ideal
              _conf(awgn=0, d=7, agc=1, ref=mejor)
              yield from _medir('ideal', k=3)
              yield from _esperar_ms(1500)
              for c in ['psd_tx_canal', 'psd_beta', 'envolvente', 'const_canal', 'ojo', 'const_rx', 'simbolos', 'ber', 'evm']:
                  _grab('ideal_' + c, c)
              self.grab().save(os.path.join(_dir, 'ventana_ideal.png'))
              # 3) Barrido del instante de muestreo (canal ideal)
              for d in range(8):
                  mejor_d = None
                  for ref in (mejor - 1, mejor, mejor + 1):
                      _conf(awgn=0, d=d, agc=1, ref=ref)
                      r = yield from _medir('muestreo_d%d_ref%d' % (d, ref), k=2)
                      if mejor_d is None or r['ber'] < mejor_d[1]:
                          mejor_d = (ref, r['ber'], r['evm_pct'])
                  _res['barrido_muestreo'].append(dict(d=d, ref=mejor_d[0], ber=mejor_d[1], evm_pct=mejor_d[2]))
                  _guardar()
                  if d in (0, 3, 6):
                      _conf(awgn=0, d=d, agc=1, ref=mejor_d[0])
                      yield from _esperar_bits(2 * self.ber_win)
                      yield from _esperar_ms(1200)
                      _grab('muestreo_d%d_const_rx' % d, 'const_rx')
              # 4) LOS nominal (Es/N0 = 30 dB)
              _conf(EsN0=30, d=7, ref=mejor)
              yield from _medir('los', k=3)
              yield from _esperar_ms(1500)
              for c in ['psd_tx_canal', 'envolvente', 'const_canal', 'ojo', 'const_rx', 'simbolos', 'ber', 'evm']:
                  _grab('los_' + c, c)
              # 5) EMI impulsiva (VFD/soldadura) sobre el LOS
              for isr in (-10.0, -5.0, 0.0, 5.0):
                  _conf(EsN0=30, emi=1, isr=isr, d=7, ref=mejor)
                  yield from _medir('emi_isr%+d' % int(isr), k=5)
              _conf(EsN0=30, emi=1, isr=0.0, d=7, ref=mejor)
              yield from _esperar_bits(2 * self.ber_win)
              yield from _esperar_ms(1500)
              for c in ['psd_tx_canal', 'envolvente', 'const_canal', 'ojo', 'const_rx', 'ber', 'evm']:
                  _grab('emi_' + c, c)
              # 5b) AWGN con la MISMA potencia media que EMI(0 dB) + fondo
              Ps = self.E_pulso / self.Sps
              duty = self.emi_rate * self.emi_dur
              P_imp = duty * Ps * 10 ** (0.0 / 10)
              P_bg = self.E_pulso / 10 ** (30.0 / 10)
              Eq = 10 * math.log10(self.E_pulso / (P_bg + P_imp))
              _conf(EsN0=Eq, emi=0, d=7, ref=mejor)
              yield from _medir('awgn_equivalente_emi', k=3, extra=dict(EsN0_equivalente=Eq, duty=duty))
              yield from _esperar_ms(1200)
              _grab('awgn_equiv_const_rx', 'const_rx')
              # 6) Sombra sin AGC (prueba fallida) y con AGC
              for att in (10.0, 15.0, 20.0):
                  _conf(EsN0=30, att=att, agc=0, d=7, ref=mejor)
                  yield from _medir('sombra%d_sinAGC' % int(att), k=2)
                  if att == 10.0:
                      yield from _esperar_ms(1200)
                      _grab('sombra10_sinAGC_const_rx', 'const_rx')
              for att in (10.0, 15.0, 20.0):
                  _conf(EsN0=30, att=att, agc=1, d=7, ref=mejor)
                  yield from _medir('sombra%d_conAGC' % int(att), k=6 if att == 10.0 else 3)
                  yield from _esperar_ms(1200)
                  _grab('sombra%d_conAGC_const_rx' % int(att), 'const_rx')
                  if att == 15.0:
                      _grab('sombra15_conAGC_const_canal', 'const_canal')
                      _grab('sombra15_conAGC_psd', 'psd_tx_canal')
              # 7) Curva BER vs Eb/N0 medida en GNU Radio (AWGN, sin sombra ni EMI)
              for agc in (1, 0):
                  for EbN0 in (0, 2, 4, 6, 8, 10, 12):
                      EsN0 = EbN0 + 10 * math.log10(self.bps)
                      _conf(EsN0=EsN0, agc=agc, d=7, ref=mejor)
                      k = 3 if EbN0 <= 8 else 10
                      r = yield from _medir('curva_agc%d_EbN0_%d' % (agc, EbN0), k=k)
                      _res['barrido_ber'].append(dict(agc=agc, EbN0_dB=EbN0, EsN0_dB=EsN0, ber=r['ber'], evm_pct=r['evm_pct'], bits=r['bits']))
                      _guardar()
              _conf(EsN0=30, d=7, ref=mejor)
              _res['fin'] = True
              _guardar()
          _g = _guion()
          def _paso():
              try:
                  next(_g)
              except StopIteration:
                  self._timer_captura.stop()
                  self.close()
              except Exception:
                  self._timer_captura.stop()
                  with open(os.path.join(_dir, 'error.txt'), 'w') as f:
                      f.write(traceback.format_exc())
          self._timer_captura = QtCore.QTimer()
          self._timer_captura.timeout.connect(_paso)
          self._timer_captura.start(50)
    comment: Guion automatico de pruebas
    section: main_after_start
  states: {}
- name: const_canal
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 6,0,4,2
    label1: '"Canal"'
    legend: 'False'
    name: '"Plano I-Q sobremuestreado (salida del canal)"'
    size: '4096'
    type: complex
    update_time: '0.1'
  states: {}
- name: const_rx
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 6,4,4,2
    label1: '"Rx"'
    legend: 'False'
    name: '"Constelacion recuperada (1 muestra/simbolo)"'
    size: '2048'
    type: complex
    update_time: '0.1'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: envolvente_canal
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 2,4,4,2
    label1: I
    label2: Q
    name: '"Envolvente compleja a la salida del canal"'
    size: '4096'
    srate: samp_rate
    type: complex
    update_time: '0.1'
    ylabel: Amplitud
    ymax: '3'
    ymin: '-3'
  states: {}
- name: evm_error
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: evm_mag2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: evm_num
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 10,4,3,2
    label1: EVM
    max: '40'
    min: '0'
    name: '"EVM rms"'
    type: float
    unit1: '%'
    update_time: '0.2'
  states: {}
- name: evm_pct
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: evm_promedio
  id: blocks_moving_average_xx
  parameters:
    length: '20000'
    max_iter: '4000'
    scale: 1/20000
    type: float
  states: {}
- name: evm_raiz
  id: blocks_transcendental
  parameters:
    name: sqrt
    type: float
  states: {}
- name: fuente_bits
  id: analog_random_source_x
  parameters:
    comment: Bits aleatorios (2^17, periodo largo)
    max: '2'
    min: '0'
    num_samps: '131072'
    repeat: 'True'
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: |-
      import math
      from gnuradio import digital
      from gnuradio.filter import firdes
  states: {}
- name: mapeo_16qam
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Mapeo Gray
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tabla_de_verdad_constelacion
  states: {}
- name: ojo_filtro_acoplado
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 6,2,4,2
    label1: I (filtro acoplado)
    label2: Q (filtro acoplado)
    samp_per_symbol: Sps
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.1'
    ylabel: Amplitud
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: probe_ber
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_evm
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: psd_beta
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    color1: '"green"'
    color2: '"blue"'
    color3: '"red"'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,2,4,2
    label1: beta = 0.20
    label2: beta = 0.35 (diseno)
    label3: beta = 0.50
    name: '"PSD Tx para distintos roll-off"'
    nconnections: '3'
    type: complex
    update_time: '0.1'
    width2: '2'
    ymax: '-10'
    ymin: '-120'
  states: {}
- name: psd_tx_canal
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,4,2
    label1: Tx (RRC)
    label2: Salida del canal
    name: '"PSD: salida RRC Tx vs salida del canal"'
    nconnections: '2'
    type: complex
    update_time: '0.1'
    ymax: '-10'
    ymin: '-120'
  states: {}
- name: ref_float
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: ref_retardo
  id: blocks_delay
  parameters:
    comment: Alinea la referencia Tx
    delay: retardo_ref
    type: byte
  states: {}
- name: rrc_b020
  id: interp_fir_filter_xxx
  parameters:
    comment: beta = 0.20 (comparacion)
    interp: Sps
    taps: firdes.root_raised_cosine(Sps, samp_rate, Rs, 0.20, span*Sps)
    type: ccf
  states: {}
- name: rrc_b050
  id: interp_fir_filter_xxx
  parameters:
    comment: beta = 0.50 (comparacion)
    interp: Sps
    taps: firdes.root_raised_cosine(Sps, samp_rate, Rs, 0.50, span*Sps)
    type: ccf
  states: {}
- name: rrc_tx
  id: interp_fir_filter_xxx
  parameters:
    comment: Conformador RRC Tx
    interp: Sps
    taps: rrc_tx_taps
    type: ccf
  states: {}
- name: ruido_awgn
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    comment: Ruido de fondo
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: ruido_emi
  id: epy_block
  parameters:
    _source_code: |
      """
      Ruido impulsivo EMI (modelo Bernoulli-Gaussiano por rafagas).

      Representa las rafagas de interferencia que producen los variadores de
      frecuencia (VFD) y equipos de soldadura de la celda: cada conmutacion genera
      una rafaga de ruido gaussiano complejo de duracion 'dur'. Las rafagas llegan
      como un proceso de Poisson de tasa 'rate' (rafagas/s). Fuera de las rafagas
      la salida es cero (el ruido de fondo lo aporta el bloque AWGN).

      Parametros
        samp_rate : tasa de muestreo [muestras/s]
        rate      : rafagas por segundo (~2*f_PWM del variador)
        dur       : duracion de cada rafaga [s]
        amp       : amplitud RMS compleja del ruido dentro de la rafaga
        enable    : 1 = activo, 0 = apagado
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, samp_rate=24e6, rate=16e3, dur=1e-6, amp=1.0, enable=0):
              gr.sync_block.__init__(self, name='Ruido impulsivo EMI',
                                     in_sig=None, out_sig=[np.complex64])
              self.samp_rate = samp_rate
              self.rate = rate
              self.dur = dur
              self.amp = amp
              self.enable = enable
              self._rng = np.random.default_rng(12345)
              self._resto = 0  # muestras pendientes de una rafaga que viene del buffer anterior

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)
              out[:] = 0
              if (not self.enable) or self.amp <= 0:
                  self._resto = 0
                  return n
              L = max(1, int(round(self.dur * self.samp_rate)))
              p = min(1.0, self.rate / self.samp_rate)
              mask = np.zeros(n, dtype=bool)
              mask[:min(self._resto, n)] = True
              resto = max(self._resto - n, 0)
              for s in np.flatnonzero(self._rng.random(n) < p):
                  mask[s:s + L] = True
                  resto = max(resto, s + L - n)
              self._resto = resto
              m = int(mask.sum())
              if m:
                  ruido = (self._rng.standard_normal(m) + 1j * self._rng.standard_normal(m)) * (self.amp / np.sqrt(2))
                  out[mask] = ruido.astype(np.complex64)
              return n
    amp: emi_amp
    comment: EMI impulsiva Bernoulli-Gaussiana
    dur: emi_dur
    enable: emi_on
    rate: emi_rate
    samp_rate: samp_rate
  states: {}
- name: rx_agc
  id: analog_agc_xx
  parameters:
    comment: Compensa la atenuacion (sombra)
    gain: '1.0'
    max_gain: '100'
    rate: agc_rate*agc_on
    reference: ref_agc
    type: complex
  states: {}
- name: rx_ajuste_muestreo
  id: blocks_delay
  parameters:
    comment: Fase de muestreo
    delay: d_muestreo
    type: complex
  states: {}
- name: rx_decisor
  id: digital_constellation_decoder_cb
  parameters:
    comment: Minima distancia
    constellation: constelacion_16qam
  states: {}
- name: rx_filtro_acoplado
  id: fir_filter_xxx
  parameters:
    comment: Filtro acoplado RRC
    decim: '1'
    taps: rrc_rx_taps
    type: ccf
  states: {}
- name: rx_float
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: rx_muestreo
  id: blocks_keep_one_in_n
  parameters:
    comment: 1 muestra por simbolo
    n: Sps
    type: complex
  states: {}
- name: rx_punto_ideal
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tabla_de_verdad_constelacion
  states: {}
- name: simbolos_tx_rx
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 10,0,3,2
    label1: Tx (referencia)
    label2: Rx (decisor)
    marker2: '0'
    name: '"Simbolos transmitidos vs recuperados (indice 0-15)"'
    nconnections: '2'
    size: '48'
    srate: Rs
    style2: '0'
    type: float
    update_time: '0.1'
    width1: '2'
    ylabel: Indice de simbolo
    ymax: '16'
  states: {}
- name: throttle_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}

connections:
- [ber_float, '0', ber_promedio, '0']
- [ber_promedio, '0', ber_num, '0']
- [ber_promedio, '0', probe_ber, '0']
- [ber_unpack, '0', ber_float, '0']
- [ber_xor, '0', ber_unpack, '0']
- [bits_a_simbolos, '0', mapeo_16qam, '0']
- [bits_a_simbolos, '0', ref_retardo, '0']
- [canal_sombra, '0', canal_suma, '0']
- [canal_suma, '0', const_canal, '0']
- [canal_suma, '0', envolvente_canal, '0']
- [canal_suma, '0', psd_tx_canal, '1']
- [canal_suma, '0', rx_filtro_acoplado, '0']
- [evm_error, '0', evm_mag2, '0']
- [evm_mag2, '0', evm_promedio, '0']
- [evm_pct, '0', evm_num, '0']
- [evm_pct, '0', probe_evm, '0']
- [evm_promedio, '0', evm_raiz, '0']
- [evm_raiz, '0', evm_pct, '0']
- [fuente_bits, '0', bits_a_simbolos, '0']
- [mapeo_16qam, '0', rrc_b020, '0']
- [mapeo_16qam, '0', rrc_b050, '0']
- [mapeo_16qam, '0', rrc_tx, '0']
- [ref_float, '0', simbolos_tx_rx, '0']
- [ref_retardo, '0', ber_xor, '0']
- [ref_retardo, '0', ref_float, '0']
- [rrc_b020, '0', psd_beta, '0']
- [rrc_b050, '0', psd_beta, '2']
- [rrc_tx, '0', throttle_0, '0']
- [ruido_awgn, '0', canal_suma, '1']
- [ruido_emi, '0', canal_suma, '2']
- [rx_agc, '0', const_rx, '0']
- [rx_agc, '0', evm_error, '0']
- [rx_agc, '0', rx_decisor, '0']
- [rx_ajuste_muestreo, '0', rx_muestreo, '0']
- [rx_decisor, '0', ber_xor, '1']
- [rx_decisor, '0', rx_float, '0']
- [rx_decisor, '0', rx_punto_ideal, '0']
- [rx_filtro_acoplado, '0', ojo_filtro_acoplado, '0']
- [rx_filtro_acoplado, '0', rx_ajuste_muestreo, '0']
- [rx_float, '0', simbolos_tx_rx, '1']
- [rx_muestreo, '0', rx_agc, '0']
- [rx_punto_ideal, '0', evm_error, '1']
- [throttle_0, '0', canal_sombra, '0']
- [throttle_0, '0', psd_beta, '1']
- [throttle_0, '0', psd_tx_canal, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
